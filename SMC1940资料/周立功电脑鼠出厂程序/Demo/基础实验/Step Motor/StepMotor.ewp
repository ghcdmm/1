# IAR project StepMotor.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8n.h
  General.OGChipSelectEditMenu: LM3S615 Luminary LM3S615
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\Luminary
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk_LM3.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM3S315 Luminary LM3S315
  ICCARM.CCDefines: NDEBUG
  group lib
    $EW_DIR$/arm/lib/Luminary/: driverlib.r79
  group src
    src/: main.c
  group startup
    src/: startup.c
